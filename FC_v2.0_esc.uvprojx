# Keil uVision project FC_v2.0_esc.uvprojx, settings and files
target stm32f446ret6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FC_v2.0_esc.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group include
    ./: cmsis_armcc.h cmsis_compiler.h stm32f4xx.h stm32f446xx.h system_stm32f4xx.h core_cm4.h
  group src
    ./: main.c startup_stm32f446xx.s system_stm32f4xx.c
software components: Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1
